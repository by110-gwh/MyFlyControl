# Keil uVision project TivaFlyControl.uvprojx, settings and files
target TivaFlyControl (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1233H6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Tiva_fly +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ..\TM4C123_LIBRARY;..\CMSIS;..\DRIVER;..\SYSTEM;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM4F;..\USER;..\MODULE;..\TASK;..\MATH;..\NAVIGATION;..\CONTROL;..\BSP;..\USMART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group bsp
    ../BSP/: ist8310.c mpu6050.c VL53L1X_api.c VL53L1X_calibration.c vl53l1_platform.c vl53l1x.c
  group control
    ../CONTROL/: controller.c motor_output.c attitude_self_stabilization.c high_attitude_stabilization.c pid.c angle_control.c gyro_control.c high_control.c
  group driver
    ../DRIVER/: oled.c i2c.c time_cnt.c ppm.c key.c pwm.c debug_uart.c paramer_save.c
  group freertos
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM4F/: port.c
  group navigation
    ../NAVIGATION/: ahrs_aux.c navigation.c
  group module
    ../MODULE/: remote_control.c imu.c
  group system
    ../SYSTEM/: main.c startup_rvmdk.S
  group tilib
    ../TM4C123_LIBRARY/driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group task
    ../TASK/: main_task.c display_task.c esc_task.c fly_task.c usmart_task.c safe_task.c
  group user
    ../USER/: Filter.c
  group usmart
    ../USMART/: usmart.c usmart_config.c usmart_str.c
