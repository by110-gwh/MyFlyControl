# Keil uVision project fightcontrol.uvprojx, settings and files
target fightcontrol (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: fightcontrol +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CMSIS;..\DRIVER;..\STM32F1xx_HAL_Driver\Inc;..\SYSTEM;..\FREERTOS\include;..\FREERTOS\portable\RVDS\ARM_CM3;..\USER;..\MODULE;..\TASK;..\MATH;..\NAVIGATION;..\CONTROL;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group bsp
    ../BSP/: ist8310.c mpu6050.c
  group control
    ../CONTROL/: control.c
  group driver
    ../DRIVER/: oled.c i2c.c time_cnt.c ppm.c key.c pwm.c
  group freertos
    ../FREERTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FREERTOS/portable/MemMang/: heap_4.c
    ../FREERTOS/portable/RVDS/ARM_CM3/: port.c
  group navigation
    ../NAVIGATION/: ahrs_aux.c navigation.c
  group math
    ../MATH/: vector3.c
  group module
    ../MODULE/: remote_control.c paramer_save.c imu.c NCLink.c
  group stlib
    ../STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_rcc.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group system
    ../CMSIS/: startup_stm32f103xe.s
    ../SYSTEM/: main.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c system_stm32f1xx.c
  group task
    ../TASK/: module_task.c main_task.c display_task.c esc_task.c
  group usrt
    ../USER/: Filter.c
